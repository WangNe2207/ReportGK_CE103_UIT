# Keil uVision project i2c_rtc.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: i2c_rtc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c delay.h ds1307.c ds1307.h i2c.c i2c.h lcd.c lcd.h main.c Keypad4x4.c Keypad4x4.h
